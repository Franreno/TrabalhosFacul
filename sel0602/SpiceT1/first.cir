*Netlist do primeiro Circuito, t<0, parte esquerda.

*Fonte de tensão 18.5 (V)
V1 1 0 dc 18.5

*Resistor de 10 (ohms)
r1 1 2 10

*Indutor de 7.4 (H)
l1 2 0 7.4

*Definicao de análise de corrente contínua
.dc v1 18.5 18.5 1

*Output do valor da corrente que passa em L1
.print dc I(l1)
